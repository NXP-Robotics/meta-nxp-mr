FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://kconfiglib-transitional.patch"