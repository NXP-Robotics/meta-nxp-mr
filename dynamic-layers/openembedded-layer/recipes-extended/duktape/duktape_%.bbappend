INSANE_SKIP:duktape-dbg += "buildpaths"
