INSANE_SKIP:cups-dbg += "buildpaths"
