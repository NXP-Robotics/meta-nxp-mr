INSANE_SKIP:slang-dbg += "buildpaths"
