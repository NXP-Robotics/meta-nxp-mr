FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
	file://0001-change-dependency-from-gitlab-eigen-to-github-eigen-.patch \
"

